PACKAGECONFIG:remove:mx6 = "xcomposite-egl xcomposite-glx"
PACKAGECONFIG:remove:mx7 = "xcomposite-egl xcomposite-glx"
