FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://0001-eigen-replace-Eigen-zip-download-with-Git-clone-to-a.patch"
