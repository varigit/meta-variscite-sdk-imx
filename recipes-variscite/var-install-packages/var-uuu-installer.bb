SUMMARY = "Recipe invoking the var-uuu-installer class to build a UUU installer package"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp|mx9-nxp-bsp)"

inherit var-uuu-installer
