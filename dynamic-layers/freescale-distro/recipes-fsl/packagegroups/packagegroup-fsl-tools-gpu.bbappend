SOC_TOOLS_GPU:append:imxgpu = " \
	imx-gpu-sdk \
	imx-gpu-viv-tools \
"

