SRC_URI:remove = "git://github.com/assimp/assimp.git;protocol=https;branch=assimp_5.0_release"
SRC_URI:prepend = "git://github.com/assimp/assimp.git;protocol=https;nobranch=1 "
