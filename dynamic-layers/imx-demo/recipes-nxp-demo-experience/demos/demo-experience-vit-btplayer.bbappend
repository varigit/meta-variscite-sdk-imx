# Copyright 2023 Variscite Ltd.

# Fixup demo experience-vit-btplayer
SRC_URI:append:imx93-var-som = " file://0001-changed-BUILD_ARCH-CortexA55.patch "
