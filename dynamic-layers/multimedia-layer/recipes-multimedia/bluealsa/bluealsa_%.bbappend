SYSTEMD_AUTO_ENABLE:${PN} = "enable"
