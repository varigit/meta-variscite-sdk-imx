# add more runtime dependencies
RDEPENDS:${PN}:append = " \
	qtmultimedia-plugins \
	qtmultimedia-qmlplugins \
	qtsvg-plugins \
	qtxmlpatterns-qmlplugins \
"
