PACKAGECONFIG:append = " gstreamer webkit"

