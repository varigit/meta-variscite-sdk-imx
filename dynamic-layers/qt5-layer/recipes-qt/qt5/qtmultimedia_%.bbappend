# integrate Gtreamer optimizations
PACKAGECONFIG:append = " gstreamer"
