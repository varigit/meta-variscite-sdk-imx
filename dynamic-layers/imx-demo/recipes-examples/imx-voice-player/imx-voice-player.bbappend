DEPENDS:append = " qtquick3d"
